# IAR project IOToggle.ewp, settings and files
configuration STM32303C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303CB ST STM32F303CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; STM32F303xC
  ICCARM.IExtraOptions: -e
  ICCARM.CCIncludePath2: ..\std_lib\inc; std_lib\Include; std_lib\src; ..\cmsis; ..\Libraries\STM32F30x_StdPeriph_Driver\inc; Libraries\STM32F30x_StdPeriph_Driver\inc; ..\std_lib\Include; ..\UserDrivers; ..\IQmath_M4; ..\IQmath_M4\IQmath; ..\IQmath_M4\IQmath\ewarm-cm4\Exe; ..\FlashDRV
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IOToggle.hex
  ILINK.IlinkOutputFile: STM32303C-EVAL.out
  ILINK.IlinkIcfFile: stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group CMSIS
    ./: system_stm32f30x.c
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f30x.s
  group FlashDRV
    ../FlashDRV/: flashDrv.c flashDrv.h
  group IQmathLib
    ../IQmath_M4/IQmath/ewarm-cm4/Exe/: IQmathLib-cm4.a
  group StdPeriph_Drivers
    ../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group User
    ./: main.c stm32f30x_it.c
  group UsersDrivers
    ../UserDrivers/: crc.c crc.h enco.c uart.c uart.h
    ./: Global_define.h Global_include.h
